Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-06-04T14:52:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 04 14:52:23 2021 * Host: DESKTOP-60FQ4CG * Database: C:\Users\Grasu\AppData\Local\Temp\{A463353B-174A-4056-A13B-85CC11F27CC1}\ifc * Database version: 5507 * Database creation date: Fri Jun 04 14:52:21 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 04 14:52:21 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 04 14:52:21 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFurnishingElement: ID Visitor Trim, Furniture_Chairs_Vitra_ID_Visitor-Trim:ID Visitor Trim:5722
In: Level 1
Type - Material: 12 powder coating deep black, Saffron, Basic Dark
Type - Construction - MetaProperties_BaseOn: Glides
Type - General - Author: BIMstone; BIMObjectName: Furniture_Chairs_Vitra_ID_Visitor-Trim; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/en-us/home; NBSDescription: Office chairs; NBSReference: 45-35-20/330; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_12_57; Uniclass2015Description: Office chairs; Uniclass2015Reference: Pr_40_50_12_57; Version: 1; VersionDate: 02/06/2021
Type - Identity Data - Cost: 0; Designer: Antonio Citterio; Manufacturer: Vitra; Model: ID Visitor Trim; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://pis.vitra.com/_storage/asset/5044452/storage/master/62913552_A%20ID%20Visitor%20BA.pdf; Type Name: ID Visitor Trim
Type - Other - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Chairs; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: n/a; ExpectedLife: n/a; Family Name: Furniture_Chairs_Vitra_ID_Visitor-Trim; Features: n/a; Finish: n/a; Grade: n/a; Material: Textile&Metal; ModelNumber: n/a; ModelReference: n/a; Name: ID_Visitor-Trim; ReplacementCost: n/a; Shape: Sculptured; Size: 550x560x845 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Construction - MetaProperties_Seat: Standard; Non-Stackable: no; SeatType_Standard: yes; Stackable: yes
Dimensions - Area: 1.29064 m2; Volume: 0.27537 m3
Materials and Finishes - ArmrestMaterial: Basic Dark; BackrestMaterial: Saffron; BaseMaterial: 12 powder coating deep black; SeatMaterial: Saffron
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Furniture_Chairs_Vitra_ID_Visitor-Trim: ID Visitor Trim; Family and Type: Furniture_Chairs_Vitra_ID_Visitor-Trim: ID Visitor Trim; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Chairs_Vitra_ID_Visitor-Trim: ID Visitor Trim; Type Id: Furniture_Chairs_Vitra_ID_Visitor-Trim: ID Visitor Trim; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
